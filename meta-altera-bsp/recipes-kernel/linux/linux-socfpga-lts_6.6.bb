LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

LINUX_VERSION ?= "6.6.51"
LINUX_VERSION_SUFFIX ?= "-lts"
LINUX_SRCREV ?= "7dddbad0a3a725b140b8fc4621159cd4628374a8"

SRCREV = "${LINUX_SRCREV}"

include linux-socfpga.inc
