require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION ?= "v2026.07"
UBOOT_SRCREV ?= "5ba74aeda63ed07e98670f8c2f0135de06543ba0"

SRCREV = "${UBOOT_SRCREV}"
