# Prevent inlining as done by previous HPS benchmarks
CFLAGS += "-O3 -fno-inline"
